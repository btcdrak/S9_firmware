FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://full-busybox.cfg"

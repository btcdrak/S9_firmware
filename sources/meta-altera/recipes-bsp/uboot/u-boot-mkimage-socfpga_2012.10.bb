require u-boot-mkimage-socfpga.inc

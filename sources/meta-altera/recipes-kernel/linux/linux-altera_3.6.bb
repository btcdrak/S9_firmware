DTB_SUBDIR="dts/"

KERNEL_DEVICETREE = "socfpga_cyclone5 socfpga_arria5 socfpga_vt"

require recipes-kernel/linux/linux-altera-latest.inc

